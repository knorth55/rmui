Commit message: add rmui1 description

File: rmui_description/urdf/rmui1.urdf (robot description, URDF)
Before this commit: robot rmui, 1 links, 0 joints
Links:
- removed link rmui_link
- added link rmui1_link, mass 0.5; collision box size=0.2 0.2 0.2; visual box size=0.2 0.2 0.2
